<?xml version='1.0' encoding='utf8'?>
<AUTOSAR xmlns="http://autosar.org/3.2.1" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/3.2.1 autosar_3-2-1.xsd"><TOP-LEVEL-PACKAGES /><ADMIN-DATA><SDGS><SDG GID="AutosarStudio::AutosarOptions"><SD GID="GENDIR">project-1497683437859</SD></SDG></SDGS></ADMIN-DATA></AUTOSAR>