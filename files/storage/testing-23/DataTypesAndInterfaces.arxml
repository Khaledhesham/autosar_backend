<AUTOSAR xmlns="http://autosar.org/3.2.1" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/3.2.1 autosar_3-2-1.xsd">
  <ADMIN-DATA>
    <SDGS>
      <SDG GID="AutosarStudio::AutosarOptions">
        <SD GID="GENDIR">files/storage/testing-23</SD>
      </SDG>
    </SDGS>
  </ADMIN-DATA>
<TOP-LEVEL-PACKAGES>
    <AR-PACKAGE UUID="d7f819a4-9a2c-11e7-8540-b88687f772a2">
      <SHORT_NAME>testing</SHORT_NAME>
    <SUB-PACKAGES>
        <AR-PACKAGE UUID="d7f819a5-9a2c-11e7-9038-b88687f772a2">
          <SHORT_NAME>DataTypes</SHORT_NAME>
        <ELEMENTS />
        </AR-PACKAGE>
      <AR-PACKAGE UUID="d7f819a5-9a2c-11e7-9038-b88687f772a2">
          <SHORT_NAME>Interfaces</SHORT_NAME>
        <ELEMENTS />
        </AR-PACKAGE>
      </SUB-PACKAGES>
    </AR-PACKAGE>
  </TOP-LEVEL-PACKAGES>
</AUTOSAR>
