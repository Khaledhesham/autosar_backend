<AUTOSAR xmlns="http://autosar.org/3.2.1" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/3.2.1 autosar_3-2-1.xsd">
  <ADMIN-DATA>
    <SDGS>
      <SDG GID="AutosarStudio::AutosarOptions">
        <SD GID="GENDIR">files/storage/seat-heater-18</SD>
      </SDG>
    </SDGS>
  </ADMIN-DATA>
<TOP-LEVEL-PACKAGES>
    <AR-PACKAGE UUID="d23ba478-644b-11e7-b4b9-b88687f772a2">
      <SHORT_NAME>seat-heater</SHORT_NAME>
    <SUB-PACKAGES>
        <AR-PACKAGE UUID="d23ba479-644b-11e7-9cb1-b88687f772a2">
          <SHORT_NAME>DataTypes</SHORT_NAME>
        <ELEMENTS />
        </AR-PACKAGE>
      <AR-PACKAGE UUID="d23ba479-644b-11e7-9cb1-b88687f772a2">
          <SHORT_NAME>Interfaces</SHORT_NAME>
        <ELEMENTS />
        </AR-PACKAGE>
      </SUB-PACKAGES>
    </AR-PACKAGE>
  </TOP-LEVEL-PACKAGES>
</AUTOSAR>
